# IAR project RTOSDemo.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F572NN R5F572NN
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0
  General.IStackSize: 0x400
  General.HeapSize: 0
  ICCRX.CCDefines: __RX; DISABLE_DEBUG_CONSOLE; RENESAS_SIMULATOR_DEBUGGING=1
  ICCRX.CCDiagSuppress: Pa091,Pe177
  ICCRX.CCIncludePath2: ..\FreeRTOS-Plus\Source\FreeRTOS-Plus-CLI; ..\FreeRTOS\Demo\Common\include; src\FreeRTOS_Demo\Full_Demo; src\FreeRTOS_Demo; src; src\smc_workaround; src\smc_workaround\r_bsp_patch; src\FreeRTOS\Source\include; src\FreeRTOS\Source\portable\IAR\RX_RenesasSim; src\frtos_startup; src\frtos_config; src\frtos_skeleton; src\smc_gen\r_bsp; src\smc_gen\r_config; src\smc_gen\r_gpio_rx; src\smc_gen\r_gpio_rx\src; src\smc_gen\general; src\smc_gen\r_pincfg
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\; src
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RX)
  as the first configuration, except:
  General.OGChipSelectMenu: RX600 Generic RX600
  General.StackSize: 0x100
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDefines: NDEBUG
  ICCRX.CCIncludePath2: C:\Renesas\GitHubDesktop\work\FreeRTOS\FreeRTOS\Demo\RX700_RX72N_RenesasSim_IAR_e2studio_EWRX\src\smc_gen\general; C:\Renesas\GitHubDesktop\work\FreeRTOS\FreeRTOS\Demo\RX700_RX72N_RenesasSim_IAR_e2studio_EWRX\src\smc_gen\r_bsp; C:\Renesas\GitHubDesktop\work\FreeRTOS\FreeRTOS\Demo\RX700_RX72N_RenesasSim_IAR_e2studio_EWRX\src\smc_gen\r_config; C:\Renesas\GitHubDesktop\work\FreeRTOS\FreeRTOS\Demo\RX700_RX72N_RenesasSim_IAR_e2studio_EWRX\src\smc_gen\r_gpio_rx; C:\Renesas\GitHubDesktop\work\FreeRTOS\FreeRTOS\Demo\RX700_RX72N_RenesasSim_IAR_e2studio_EWRX\src\smc_gen\r_pincfg; C:\Renesas\GitHubDesktop\work\FreeRTOS\FreeRTOS\Demo\RX700_RX72N_RenesasSim_IAR_e2studio_EWRX\src\smc_gen\r_gpio_rx\src
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  group (top)
    ./: SmartConfigurator.ipcf
  group FreeRTOS
    src/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/include
    src/FreeRTOS/Source/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group FreeRTOS/portable
    src/FreeRTOS/Source/portable/IAR/RX_RenesasSim/: port.c portmacro.h
  group FreeRTOS/portable/MemMang
    src/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group FreeRTOS_Demo
    src/FreeRTOS_Demo/: demo_main.h demo_specific_io.h
  group FreeRTOS_Demo/Blinky_Demo
    src/FreeRTOS_Demo/Blinky_Demo/: main_blinky.c
  group FreeRTOS_Demo/Full_Demo
    src/FreeRTOS_Demo/Full_Demo/: IntQueueTimer.c IntQueueTimer.h main_full.c serial.c
  group FreeRTOS_Demo/Full_Demo/FreeRTOS+CLI
    ../FreeRTOS-Plus/Source/FreeRTOS-Plus-CLI/: FreeRTOS_CLI.c
    ../FreeRTOS-Plus/Demo/Common/FreeRTOS_Plus_CLI_Demos/: Sample-CLI-commands.c UARTCommandConsole.c
  group FreeRTOS_Demo/Full_Demo/Standard_Demo_Tasks
    ../FreeRTOS/Demo/Common/Minimal/: BlockQ.c blocktim.c countsem.c death.c dynamic.c EventGroupsDemo.c flop.c GenQTest.c IntQueue.c IntSemTest.c QueueOverwrite.c recmutex.c semtest.c TaskNotify.c TaskNotifyArray.c TimerDemo.c
  group frtos_config
    src/frtos_config/: FreeRTOSConfig.h
  group frtos_skeleton
    src/frtos_skeleton/: task_function.h
  group frtos_startup
    src/frtos_startup/: freertos_object_init.c freertos_start.c freertos_start.h
  group Renesas_AP/smc_gen/general
    src/smc_gen/general/: r_cg_hardware_setup.c r_cg_macrodriver.h r_cg_userdefine.h r_smc_cgc.c r_smc_cgc.h r_smc_cgc_user.c r_smc_entry.h r_smc_interrupt.c r_smc_interrupt.h
  group Renesas_AP/smc_gen/r_bsp
    src/smc_gen/r_bsp/: platform.h readme.txt
  group Renesas_AP/smc_gen/r_bsp/board/generic_rx72n
    src/smc_gen/r_bsp/board/generic_rx72n/: hwsetup.c hwsetup.h r_bsp.h r_bsp_config_reference.h r_bsp_interrupt_config_reference.h
  group Renesas_AP/smc_gen/r_bsp/board/user
    src/smc_gen/r_bsp/board/user/: r_bsp.h
  group Renesas_AP/smc_gen/r_bsp/doc/en
    src/smc_gen/r_bsp/doc/en/: r01an1685ej0561-rx-bsp.pdf
  group Renesas_AP/smc_gen/r_bsp/doc/ja
    src/smc_gen/r_bsp/doc/ja/: r01an1685jj0561-rx-bsp.pdf
  group Renesas_AP/smc_gen/r_bsp/mcu/all
    src/smc_gen/r_bsp/mcu/all/: lowlvl.h lowsrc.h mcu_locks.c r_bsp_common.c r_bsp_common.h r_bsp_cpu.c r_bsp_interrupts.c r_bsp_interrupts.h r_bsp_locking.c r_bsp_mcu_startup.c r_bsp_mcu_startup.h r_bsp_software_interrupt.c r_bsp_software_interrupt.h r_rtos.h r_rx_compiler.h r_rx_intrinsic_functions.c r_rx_intrinsic_functions.h r_typedefs.h resetprg.c
  group Renesas_AP/smc_gen/r_bsp/mcu/rx72n
    src/smc_gen/r_bsp/mcu/rx72n/: mcu_clocks.c mcu_clocks.h mcu_info.h mcu_init.c mcu_init.h mcu_interrupts.c mcu_interrupts.h mcu_locks.h mcu_mapped_interrupts.c mcu_mapped_interrupts.h mcu_mapped_interrupts_private.h r_bsp_cpu.h r_bsp_locking.h vecttbl.c vecttbl.h
  group Renesas_AP/smc_gen/r_bsp/mcu/rx72n/register_access/iccrx
    src/smc_gen/r_bsp/mcu/rx72n/register_access/iccrx/: iodefine.h
  group Renesas_AP/smc_gen/r_config
    src/smc_gen/r_config/: r_bsp_config.h r_bsp_config_readme.txt r_bsp_interrupt_config.h r_byteq_config.h r_dtc_rx_config.h r_gpio_rx_config.h r_sci_rx_config.h
  group Renesas_AP/smc_gen/r_gpio_rx
    src/smc_gen/r_gpio_rx/: r_gpio_rx_if.h readme.txt
  group Renesas_AP/smc_gen/r_gpio_rx/doc/en
    src/smc_gen/r_gpio_rx/doc/en/: r01an1721ej0350-rx-gpio.pdf
  group Renesas_AP/smc_gen/r_gpio_rx/doc/ja
    src/smc_gen/r_gpio_rx/doc/ja/: r01an1721jj0350-rx-gpio.pdf
  group Renesas_AP/smc_gen/r_gpio_rx/ref
    src/smc_gen/r_gpio_rx/ref/: r_gpio_rx_config_reference.h
  group Renesas_AP/smc_gen/r_gpio_rx/src
    src/smc_gen/r_gpio_rx/src/: r_gpio_rx.c
  group Renesas_AP/smc_gen/r_gpio_rx/src/targets/rx72n
    src/smc_gen/r_gpio_rx/src/targets/rx72n/: r_gpio_rx72n.c r_gpio_rx72n.h
  group Renesas_AP/smc_gen/r_pincfg
    src/smc_gen/r_pincfg/: Pin.c Pin.h
  group Renesas_AP_tips/smc_workaround
    src/smc_workaround/: CC_patch.h CG_patch.h FIT_patch.c FIT_patch.h FIT_patch2.h IDE_helper.c IDE_helper.h IDE_patch.h sim_debug_mode_hook.c sim_debug_mode_hook.h smc_workaround.h u_bsp_lowlvl_ext.c u_bsp_lowlvl_ext.h
  group Renesas_AP_tips/smc_workaround/r_bsp_patch
    src/smc_workaround/r_bsp_patch/: lowlvl.c platform.h
